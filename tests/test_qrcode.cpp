// SPDX-License-Identifier: GPL-3.0-or-later
//
// Unit tests for the QR Code generator (qr_encode.c / qr_encode.h).

#include "qr_encode.h"
#include "golden_shares.h"

extern "C"
{
}

#include <cstring>
#include <gtest/gtest.h>
#include <string>

// ===========================================================================
// Test helpers
// ===========================================================================

namespace
{

// Buffer large enough for any QR Code (version 40).
constexpr size_t kBufLen = qrcodegen_BUFFER_LEN_MAX;

/**
 * @brief Read a single module (pixel) of the QR Code grid.
 *
 * Mirrors the internal getModuleBounded() layout: qrcode[0] holds the side
 * length, the module grid is packed from byte 1, row-major, LSB first.
 *
 * @param qrcode  QR Code buffer produced by qrcodegen_encodeText().
 * @param x       Column (0 = left).
 * @param y       Row (0 = top).
 * @return true if the module is dark, false if light or out of bounds.
 */
bool getModule(const uint8_t qrcode[], int x, int y)
{
    int size = qrcode[0];
    if (x < 0 || y < 0 || x >= size || y >= size)
    {
        return false;
    }
    int index = y * size + x;
    return ((qrcode[(index >> 3) + 1] >> (index & 7)) & 1) != 0;
}

/**
 * @brief Encode text and return the QR Code buffer.
 *
 * @param text  UTF-8 text to encode.
 * @return true on success, false on failure.
 */
bool encodeText(const std::string &text, uint8_t qrcode[kBufLen])
{
    uint8_t temp[kBufLen];
    return qrcodegen_encodeText(text.c_str(), temp, qrcode);
}

/**
 * @brief Check that the three finder patterns (position detection squares)
 *        are present at the expected corners of the QR Code.
 *
 * Each finder pattern is a 7x7 dark square with a 3x3 dark center and a
 * 1-module light ring. We verify the four corners of the outer square and
 * the center module.
 *
 * @param qrcode  QR Code buffer.
 * @param size    Side length in modules.
 */
void expectFinderPattern(const uint8_t qrcode[], int size, int ox, int oy)
{
    // Outer 7x7 square corners are dark.
    EXPECT_TRUE(getModule(qrcode, ox, oy));
    EXPECT_TRUE(getModule(qrcode, ox + 6, oy));
    EXPECT_TRUE(getModule(qrcode, ox, oy + 6));
    EXPECT_TRUE(getModule(qrcode, ox + 6, oy + 6));

    // Center 3x3 square is dark.
    EXPECT_TRUE(getModule(qrcode, ox + 3, oy + 3));

    // The ring just inside the outer square is light (separator).
    EXPECT_FALSE(getModule(qrcode, ox + 1, oy + 1));
    EXPECT_FALSE(getModule(qrcode, ox + 5, oy + 1));
    EXPECT_FALSE(getModule(qrcode, ox + 1, oy + 5));
    EXPECT_FALSE(getModule(qrcode, ox + 5, oy + 5));
}

} // namespace

// ===========================================================================
// Test fixture
// ===========================================================================

class QRCodeTest : public ::testing::Test
{
  protected:
    uint8_t qrcode_[kBufLen];
    uint8_t temp_[kBufLen];
};

// ===========================================================================
// Tests
// ===========================================================================

// ---------------------------------------------------------------------------
// Basic encoding
// ---------------------------------------------------------------------------

TEST_F(QRCodeTest, EncodeShortText)
{
    ASSERT_TRUE(qrcodegen_encodeText("HELLO WORLD", temp_, qrcode_));
    int size = qrcodegen_getSize(qrcode_);
    EXPECT_GE(size, 21); // version 1 minimum
    EXPECT_LE(size, 177); // version 40 maximum
    EXPECT_EQ(size % 4, 1); // size = 4*version + 17
}

TEST_F(QRCodeTest, EncodeEmptyString)
{
    ASSERT_TRUE(qrcodegen_encodeText("", temp_, qrcode_));
    EXPECT_GE(qrcodegen_getSize(qrcode_), 21);
}

TEST_F(QRCodeTest, EncodeDigitsText)
{
    // Digits are valid alphanumeric characters (encoded in alphanumeric mode).
    ASSERT_TRUE(qrcodegen_encodeText("0123456789", temp_, qrcode_));
    EXPECT_GE(qrcodegen_getSize(qrcode_), 21);
}

TEST_F(QRCodeTest, EncodeAlphanumericText)
{
    // Alphanumeric mode: uppercase letters, digits and a few symbols.
    ASSERT_TRUE(qrcodegen_encodeText("HELLO WORLD 123", temp_, qrcode_));
    EXPECT_GE(qrcodegen_getSize(qrcode_), 21);
}

// ---------------------------------------------------------------------------
// Size / version selection
// ---------------------------------------------------------------------------

TEST_F(QRCodeTest, SizeIncreasesWithContentLength)
{
    std::string shortText = "A";
    std::string longText(200, 'A');

    uint8_t shortQr[kBufLen];
    uint8_t longQr[kBufLen];

    ASSERT_TRUE(encodeText(shortText, shortQr));
    ASSERT_TRUE(encodeText(longText, longQr));

    int shortSize = qrcodegen_getSize(shortQr);
    int longSize = qrcodegen_getSize(longQr);

    EXPECT_GE(longSize, shortSize) << "Longer content should not produce a smaller QR Code";
}

TEST_F(QRCodeTest, SizeIsMultipleOfFourPlusOne)
{
    ASSERT_TRUE(qrcodegen_encodeText("RELIC CORE", temp_, qrcode_));
    int size = qrcodegen_getSize(qrcode_);
    EXPECT_EQ((size - 17) % 4, 0);
    EXPECT_GE(size, 21);
    EXPECT_LE(size, 177);
}

// ---------------------------------------------------------------------------
// Determinism
// ---------------------------------------------------------------------------

TEST_F(QRCodeTest, SameInputProducesSameOutput)
{
    uint8_t qr1[kBufLen];
    uint8_t qr2[kBufLen];

    ASSERT_TRUE(encodeText("DETERMINISTIC", qr1));
    ASSERT_TRUE(encodeText("DETERMINISTIC", qr2));

    int size = qrcodegen_getSize(qr1);
    ASSERT_EQ(size, qrcodegen_getSize(qr2));

    // Compare the full grid (byte 0 = size, then the module bytes).
    size_t bytes = (size * size + 7) / 8 + 1;
    EXPECT_EQ(std::memcmp(qr1, qr2, bytes), 0) << "Same input must produce identical QR Codes";
}

TEST_F(QRCodeTest, DifferentInputProducesDifferentOutput)
{
    uint8_t qr1[kBufLen];
    uint8_t qr2[kBufLen];

    ASSERT_TRUE(encodeText("FIRST", qr1));
    ASSERT_TRUE(encodeText("SECOND", qr2));

    int size = qrcodegen_getSize(qr1);
    ASSERT_EQ(size, qrcodegen_getSize(qr2));

    size_t bytes = (size * size + 7) / 8 + 1;
    EXPECT_NE(std::memcmp(qr1, qr2, bytes), 0) << "Different inputs should produce different QR Codes";
}

// ---------------------------------------------------------------------------
// Structure: finder patterns
// ---------------------------------------------------------------------------

TEST_F(QRCodeTest, FinderPatternsPresent)
{
    ASSERT_TRUE(qrcodegen_encodeText("RELIC CORE", temp_, qrcode_));
    int size = qrcodegen_getSize(qrcode_);

    // Top-left, top-right and bottom-left finder patterns.
    expectFinderPattern(qrcode_, size, 0, 0);
    expectFinderPattern(qrcode_, size, size - 7, 0);
    expectFinderPattern(qrcode_, size, 0, size - 7);
}

TEST_F(QRCodeTest, NotUniformGrid)
{
    ASSERT_TRUE(qrcodegen_encodeText("NOT UNIFORM TEST", temp_, qrcode_));
    int size = qrcodegen_getSize(qrcode_);

    // A valid QR Code is never a solid block: it must contain both dark and
    // light modules. Count the dark modules and ensure it is neither empty
    // nor the whole grid.
    int darkCount = 0;
    for (int y = 0; y < size; y++)
    {
        for (int x = 0; x < size; x++)
        {
            if (getModule(qrcode_, x, y))
            {
                darkCount++;
            }
        }
    }

    EXPECT_GT(darkCount, 0) << "QR Code should contain at least one dark module";
    EXPECT_LT(darkCount, size * size) << "QR Code should not be entirely dark";
}

// ---------------------------------------------------------------------------
// Error cases
// ---------------------------------------------------------------------------

TEST_F(QRCodeTest, TextTooLongFails)
{
    // A very long text that cannot fit in any version (1..40) at ECC LOW.
    std::string tooLong(5000, 'X');
    EXPECT_FALSE(qrcodegen_encodeText(tooLong.c_str(), temp_, qrcode_));
    EXPECT_EQ(qrcode_[0], 0) << "qrcode[0] should be set to 0 (invalid size sentinel) on failure";
}

TEST_F(QRCodeTest, NullTextFails)
{
    EXPECT_FALSE(qrcodegen_encodeText(nullptr, temp_, qrcode_));
}

TEST_F(QRCodeTest, NullBuffersFail)
{
    EXPECT_FALSE(qrcodegen_encodeText("TEST", nullptr, qrcode_));
    EXPECT_FALSE(qrcodegen_encodeText("TEST", temp_, nullptr));
}

TEST_F(QRCodeTest, GetSizeNullReturnsMinusOne)
{
    EXPECT_EQ(qrcodegen_getSize(nullptr), -1);
}

// ---------------------------------------------------------------------------
// Capacity / boundary
// ---------------------------------------------------------------------------

TEST_F(QRCodeTest, DigitsCapacityFits)
{
    // Digits are valid alphanumeric characters; a 100-digit string should fit easily.
    std::string digits(100, '7');
    ASSERT_TRUE(encodeText(digits, qrcode_));
    EXPECT_GE(qrcodegen_getSize(qrcode_), 21);
}

TEST_F(QRCodeTest, AlphanumericCapacityBoundary)
{
    // Alphanumeric mode: ~4296 chars fit in version 40 at ECC LOW. Use a value
    // well within range but large enough to require a high version.
    std::string text(1000, 'A');
    ASSERT_TRUE(encodeText(text, qrcode_));
    int size = qrcodegen_getSize(qrcode_);
    EXPECT_GT(size, 21) << "1000 chars should require a version larger than 1";
}


// ---------------------------------------------------------------------------
// Real cases deterministic tests from pre-generated QR codes that we know are true
// ---------------------------------------------------------------------------
//
// These tests are generated from an edge case scenario: a 24-word seed phrase
//
//   "abandon abandon abandon abandon abandon abandon abandon abandon abandon
//    abandon abandon abandon abandon abandon abandon abandon abandon abandon
//    abandon abandon abandon abandon abandon art"
//
// The shares have been generated from this phrase and encoded as QR codes
// (version 10, 57x57 modules). The golden QR grid byte arrays below were
// produced by the reference encoder at build time (Relic Core v1.2.3 on an
// ESP32-DevKitV1) and are stored here so that re-encoding the same uppercased
// share string must reproduce the exact same grid byte-for-byte. This guards
// against any regression that would silently change the generated QR codes.
//
// NOTE: the golden grids correspond to the UPPERCASED share strings (the
// front-end uppercases the hex payload before requesting the QR code). The
// encode helper below applies the same uppercasing before encoding.

namespace
{

// Golden QR grids for the five shares above (version 10, 57x57 modules).
// qrcode[0] holds the side length (57) and the module grid is packed from
// byte 1, row-major, LSB first — see getModule().
static const uint8_t seedphrase_share1_qr[] = {
    0x39, 0x7F, 0x9B, 0x73, 0xC6, 0x92, 0xD6, 0xFC, 0x83, 0x6C, 0xD1, 0x09, 0x9C, 0x02, 0x09, 0x76, 0x8D, 0x24, 0xC2,
    0xCB, 0xA8, 0xD3, 0xED, 0xAA, 0x75, 0x7D, 0x78, 0x68, 0xA5, 0xDB, 0x95, 0x5D, 0xCB, 0xAF, 0x44, 0x49, 0x37, 0x08,
    0x88, 0xFC, 0x38, 0xEE, 0x89, 0xE0, 0x5F, 0x55, 0x55, 0x55, 0x55, 0x55, 0x7F, 0x00, 0xE6, 0x6B, 0xA3, 0xCA, 0x7B,
    0x00, 0x4F, 0x9F, 0x69, 0x7C, 0x6B, 0x4F, 0x73, 0x7D, 0xA7, 0x83, 0xE6, 0x28, 0xA5, 0xC0, 0x87, 0x03, 0xD7, 0xB4,
    0x46, 0x70, 0xDE, 0x1E, 0x70, 0xE8, 0xED, 0x2F, 0xE9, 0xC3, 0xD5, 0x5D, 0x39, 0x42, 0x65, 0xC8, 0x22, 0x0A, 0xE0,
    0x4C, 0x17, 0x34, 0xB8, 0xF0, 0x14, 0x17, 0xCA, 0x84, 0x6C, 0xA2, 0xB5, 0x98, 0x58, 0x45, 0x12, 0x37, 0x81, 0xCB,
    0x98, 0x5E, 0x6A, 0x96, 0xCA, 0x1F, 0xAE, 0x00, 0x7D, 0xA7, 0xBA, 0x04, 0xA1, 0x92, 0x6E, 0x24, 0xD3, 0xC9, 0x31,
    0x1B, 0x00, 0x69, 0x44, 0x14, 0x6C, 0x6C, 0xC9, 0xB4, 0x6F, 0x6C, 0x66, 0x9D, 0xC6, 0x0E, 0x10, 0xD1, 0x85, 0x63,
    0x93, 0xAF, 0x6B, 0x7D, 0xEE, 0x22, 0xDA, 0xA4, 0x31, 0x51, 0x97, 0x85, 0xFB, 0xCF, 0xA6, 0x68, 0x4D, 0x44, 0x0C,
    0x11, 0xDA, 0xED, 0x09, 0xCF, 0xB4, 0x1F, 0x54, 0x12, 0x6F, 0x26, 0xCC, 0x9A, 0xE6, 0x4A, 0xDE, 0xC7, 0xA5, 0xF1,
    0x01, 0x10, 0xFD, 0xF7, 0xB8, 0xFF, 0x2D, 0x22, 0xAB, 0x89, 0x66, 0x15, 0x36, 0x7E, 0x25, 0x29, 0x5D, 0x77, 0xA3,
    0x4C, 0xF6, 0x98, 0x20, 0x2A, 0x96, 0x7D, 0x05, 0x39, 0x1F, 0x03, 0xC5, 0xDF, 0xC7, 0x68, 0x69, 0xA8, 0x86, 0x41,
    0x11, 0xE1, 0xB1, 0xD3, 0xE1, 0x19, 0x54, 0x1B, 0x20, 0x9C, 0xCD, 0x4E, 0xE4, 0x9A, 0xD3, 0xF4, 0xBD, 0x73, 0x92,
    0x19, 0x1A, 0x4E, 0xA4, 0x6C, 0x1B, 0x05, 0x47, 0x1E, 0xD4, 0x86, 0x6F, 0xCD, 0x26, 0xB0, 0x21, 0xB7, 0xE4, 0x24,
    0x36, 0xFA, 0x45, 0xD9, 0xB6, 0xAF, 0x99, 0x0D, 0xA1, 0xB0, 0xC5, 0xD4, 0x2C, 0x1D, 0xAE, 0x93, 0xB9, 0x25, 0xA8,
    0xF5, 0xE7, 0x55, 0x8B, 0x46, 0xC2, 0xC3, 0xAC, 0x2A, 0x80, 0xDB, 0x64, 0x79, 0xC9, 0x32, 0x21, 0x29, 0x8F, 0x84,
    0x20, 0xA5, 0x7A, 0x18, 0x81, 0xF7, 0x54, 0xFF, 0x93, 0x1A, 0x0B, 0x8E, 0xF7, 0x8C, 0x54, 0x1A, 0xC7, 0xE1, 0xC2,
    0x91, 0x16, 0x49, 0xD1, 0x99, 0x41, 0x79, 0x54, 0x3D, 0xB9, 0xB0, 0xB0, 0x9F, 0xCF, 0xAD, 0x00, 0x3E, 0x37, 0x67,
    0x57, 0x40, 0x46, 0x2C, 0x7D, 0x98, 0x6D, 0x5F, 0x01, 0xAE, 0x94, 0x8C, 0x46, 0x88, 0xE3, 0xFC, 0x51, 0xF0, 0x59,
    0xA3, 0x6D, 0xD7, 0x0F, 0xB2, 0x31, 0x2D, 0x66, 0x08, 0x88, 0xDB, 0xC5, 0x4E, 0xEB, 0xB7, 0x97, 0xF8, 0xA1, 0xAB,
    0x20, 0xBA, 0xD0, 0xC3, 0x2D, 0x77, 0xD7, 0x17, 0x2C, 0xA3, 0x60, 0x49, 0x98, 0xA0, 0x18, 0x14, 0xE8, 0x11, 0xE1,
    0x01, 0x7F, 0x3F, 0x09, 0x58, 0x86, 0x61, 0x9A, 0x00,
};

static const uint8_t seedphrase_share2_qr[] = {
    0x39, 0x7F, 0xDA, 0x8F, 0x43, 0x75, 0xCE, 0xFC, 0x83, 0x80, 0x5C, 0x5D, 0x83, 0x27, 0x09, 0x76, 0x2D, 0xC7, 0xFE,
    0x5E, 0x43, 0xD3, 0xED, 0x42, 0x34, 0x40, 0x2C, 0xD0, 0xA4, 0xDB, 0xA5, 0x0C, 0xE5, 0xF7, 0x93, 0x48, 0x37, 0xC8,
    0x3C, 0xEC, 0xC8, 0x77, 0x88, 0xE0, 0x5F, 0x55, 0x55, 0x55, 0x55, 0x55, 0x7F, 0x80, 0xB0, 0x86, 0xE3, 0x6C, 0x13,
    0x00, 0xF7, 0x67, 0x74, 0x7E, 0x57, 0x27, 0x47, 0x1E, 0x4D, 0x61, 0x93, 0x1C, 0x1C, 0xD7, 0x5C, 0x49, 0x0B, 0x11,
    0x12, 0x66, 0xCB, 0x9D, 0x35, 0x70, 0x94, 0xFC, 0x55, 0x59, 0x34, 0x27, 0xB5, 0xF5, 0x77, 0x1F, 0xAC, 0xF7, 0xA0,
    0x40, 0x3A, 0x15, 0x21, 0xAC, 0xF9, 0xFE, 0x12, 0x97, 0x70, 0xA3, 0x43, 0xA6, 0x59, 0x7B, 0xF7, 0xC1, 0x9A, 0x5B,
    0x87, 0xDD, 0xA7, 0x15, 0xCB, 0x7D, 0x3F, 0x6B, 0x71, 0xF1, 0xB8, 0x72, 0xFC, 0x3B, 0xDE, 0x45, 0xAF, 0x02, 0x26,
    0x7C, 0x55, 0x54, 0xB4, 0x40, 0x2F, 0x58, 0x50, 0x67, 0x42, 0x7C, 0xBD, 0x7A, 0x1F, 0xC2, 0xD1, 0xDD, 0xCB, 0xE6,
    0x15, 0x46, 0x56, 0x45, 0xE1, 0x06, 0x59, 0x72, 0xD8, 0x35, 0xBB, 0x50, 0xC4, 0x5C, 0x67, 0x99, 0xB6, 0x08, 0x91,
    0xF5, 0xEF, 0x12, 0xC0, 0x04, 0xD6, 0x1D, 0x20, 0x59, 0x19, 0x92, 0x9D, 0x9B, 0xC7, 0x35, 0xF5, 0x87, 0x54, 0xF7,
    0xE9, 0x7C, 0x7C, 0xA8, 0x08, 0x81, 0x2E, 0x7A, 0xDE, 0x8D, 0x8B, 0x75, 0x52, 0x5A, 0x6D, 0x10, 0x55, 0x47, 0x63,
    0x05, 0xE0, 0x08, 0x11, 0x37, 0xB6, 0xFE, 0x79, 0x36, 0xDF, 0x0B, 0xD9, 0x77, 0xDE, 0xFE, 0xB5, 0x51, 0xD4, 0x9D,
    0x65, 0x59, 0x5B, 0x44, 0xC1, 0xDD, 0x34, 0x55, 0x79, 0x46, 0x91, 0x9D, 0x33, 0x06, 0x84, 0x4A, 0x93, 0x70, 0xC5,
    0xB0, 0x78, 0x95, 0xCD, 0x59, 0x67, 0xD4, 0x21, 0x12, 0x22, 0xD3, 0x0F, 0xB0, 0x79, 0x0D, 0x15, 0x53, 0x05, 0x41,
    0x29, 0x51, 0x4C, 0x50, 0x79, 0x17, 0xB0, 0x8B, 0x77, 0x58, 0x71, 0x91, 0xD7, 0x01, 0x9D, 0x07, 0xDC, 0x4F, 0x64,
    0x87, 0x42, 0x2E, 0xC5, 0x55, 0xE0, 0x6D, 0xEC, 0x52, 0x32, 0x0E, 0x35, 0x70, 0x6D, 0x8E, 0xA6, 0xD3, 0xEB, 0x7E,
    0x2E, 0xE6, 0x65, 0xFD, 0x49, 0x73, 0x8F, 0xC5, 0x7A, 0xDA, 0x7F, 0x6D, 0xA8, 0xB5, 0x07, 0x07, 0xEB, 0xDF, 0xB6,
    0x54, 0x65, 0xC7, 0xDA, 0xE5, 0x5D, 0x39, 0x6F, 0x36, 0xE2, 0x57, 0x51, 0xD5, 0x4F, 0x0F, 0xA1, 0x86, 0x5D, 0x00,
    0x19, 0xC0, 0x52, 0x83, 0x7D, 0x53, 0x55, 0xBF, 0x01, 0xA6, 0x61, 0x8D, 0x4F, 0x23, 0xA2, 0xFE, 0xF5, 0x77, 0x55,
    0x17, 0x8F, 0xD7, 0x0A, 0xDA, 0xF5, 0x35, 0xD6, 0xDC, 0x8E, 0xD3, 0xB5, 0x7E, 0xC7, 0xC7, 0xC5, 0xF1, 0xA5, 0x0B,
    0x14, 0xDA, 0xC3, 0xD6, 0x55, 0x72, 0xD7, 0x7E, 0x69, 0x94, 0x07, 0x6D, 0xDF, 0xA0, 0x68, 0x9B, 0x2E, 0x76, 0xA7,
    0xFF, 0x7F, 0x17, 0x00, 0xA6, 0xD1, 0x72, 0x55, 0x01,
};

static const uint8_t seedphrase_share3_qr[] = {
    0x39, 0x7F, 0xD2, 0x8D, 0x4A, 0x17, 0xD5, 0xFC, 0x83, 0x7C, 0xE2, 0x59, 0x49, 0x70, 0x09, 0x76, 0x5D, 0x55, 0x11,
    0x1F, 0xDE, 0xD3, 0xED, 0x12, 0x17, 0xC0, 0x87, 0x3F, 0xA4, 0xDB, 0x65, 0x6C, 0xD7, 0xC7, 0x76, 0x4B, 0x37, 0x48,
    0x3E, 0xA0, 0x58, 0xF5, 0x88, 0xE0, 0x5F, 0x55, 0x55, 0x55, 0x55, 0x55, 0x7F, 0x80, 0x96, 0x57, 0xE3, 0x62, 0x12,
    0x00, 0xF7, 0x23, 0x55, 0x7C, 0xA7, 0x93, 0x47, 0x16, 0xE0, 0xA5, 0x65, 0xB9, 0xFF, 0x97, 0x7A, 0x69, 0x6D, 0x7A,
    0x50, 0x8D, 0x88, 0x8F, 0xE1, 0x7C, 0x93, 0xFE, 0xF5, 0x68, 0x09, 0x66, 0x3D, 0x1D, 0x50, 0x8D, 0x6C, 0x5F, 0xC7,
    0x60, 0x3B, 0xFF, 0x2B, 0x24, 0x8C, 0x3E, 0xDD, 0x63, 0x21, 0xF4, 0x3C, 0x08, 0xCB, 0x48, 0x45, 0x13, 0x05, 0x20,
    0xBF, 0xED, 0xF7, 0x18, 0x81, 0xB4, 0xDB, 0x55, 0x51, 0x29, 0x3D, 0xE4, 0x2C, 0x75, 0x4E, 0x59, 0xA1, 0xE2, 0xC3,
    0x47, 0xC7, 0x50, 0x1C, 0xF8, 0x5F, 0x91, 0x5A, 0x45, 0x27, 0xED, 0x8D, 0x3A, 0xCF, 0xDF, 0x65, 0x2D, 0x21, 0xB3,
    0x57, 0xDE, 0x50, 0x77, 0xAD, 0x9C, 0x3D, 0x72, 0x49, 0x34, 0x91, 0x58, 0x34, 0x9B, 0x55, 0xD8, 0xB0, 0x5E, 0xB5,
    0xFF, 0xF7, 0xDA, 0x1C, 0xD5, 0xE0, 0xDE, 0x2A, 0x31, 0xCD, 0x02, 0xD9, 0xE6, 0xD9, 0x01, 0xED, 0xD7, 0x15, 0xF5,
    0x47, 0xD1, 0xFF, 0xAD, 0xE8, 0x8A, 0x35, 0xCA, 0xEE, 0x8C, 0x89, 0x95, 0x42, 0x4B, 0xDD, 0x38, 0x51, 0xD5, 0xE3,
    0x28, 0xF4, 0xF8, 0x71, 0x2D, 0xF6, 0xFD, 0x70, 0x4D, 0x5F, 0x88, 0xD0, 0x2F, 0x5A, 0xCB, 0x27, 0x73, 0x57, 0x81,
    0xBD, 0x5B, 0x39, 0xC8, 0xD5, 0x64, 0xCC, 0x5C, 0x1E, 0x54, 0xC5, 0x2D, 0xF7, 0xEF, 0x9D, 0xDA, 0x53, 0x51, 0xF1,
    0x7A, 0x4C, 0x94, 0xA8, 0x31, 0x85, 0x76, 0x18, 0xE8, 0xA4, 0xB5, 0x84, 0xB6, 0x49, 0xD9, 0x87, 0x55, 0xD5, 0x67,
    0x24, 0xE5, 0xC0, 0x55, 0xC7, 0xD2, 0x7C, 0x18, 0x4F, 0xD8, 0x6D, 0xBE, 0xC4, 0xD0, 0xBB, 0x05, 0x74, 0xAB, 0x56,
    0x96, 0xD7, 0xA7, 0x05, 0x99, 0xC0, 0xC8, 0xFC, 0x14, 0x23, 0x2D, 0x1D, 0xB1, 0x12, 0x74, 0xA7, 0xDB, 0x4C, 0xDD,
    0x69, 0xDD, 0x43, 0x3D, 0x95, 0x36, 0xAD, 0xDF, 0xE2, 0xD3, 0xF7, 0x66, 0x33, 0x15, 0x9B, 0x0D, 0x73, 0x5F, 0x33,
    0x42, 0x15, 0x56, 0xB8, 0x5B, 0x59, 0x59, 0x52, 0x3E, 0xCC, 0x55, 0x45, 0xD6, 0x4F, 0x61, 0xE3, 0x55, 0xF5, 0x33,
    0x9B, 0xC0, 0x26, 0x62, 0x7E, 0x57, 0x5D, 0x1F, 0x00, 0xD2, 0xF1, 0x8F, 0xC5, 0x59, 0x23, 0xFC, 0xB5, 0xE4, 0x52,
    0x01, 0x87, 0xD5, 0x0E, 0x1A, 0x12, 0x35, 0xAA, 0x35, 0x8C, 0xDD, 0x35, 0x5F, 0xE5, 0x6F, 0xAA, 0xFE, 0xB1, 0x8B,
    0x96, 0x26, 0xB7, 0x5E, 0xA4, 0x7B, 0xD7, 0xF0, 0xC9, 0x74, 0x43, 0x4D, 0xD9, 0xA0, 0x65, 0xDA, 0xD0, 0x20, 0x9D,
    0xC6, 0x7F, 0x5F, 0x42, 0x65, 0x61, 0x57, 0x5D, 0x01,
};

static const uint8_t seedphrase_share4_qr[] = {
    0x39, 0x7F, 0xD2, 0xEB, 0x2B, 0x15, 0xD4, 0xFC, 0x83, 0x56, 0x43, 0xFB, 0x46, 0x03, 0x09, 0x76, 0x65, 0x3A, 0x9B,
    0xFA, 0x2E, 0xD3, 0xED, 0x32, 0x37, 0x50, 0x2D, 0xB8, 0xA4, 0xDB, 0x55, 0x9B, 0xD1, 0x27, 0x51, 0x48, 0x37, 0xA8,
    0x30, 0x82, 0xE8, 0x03, 0x88, 0xE0, 0x5F, 0x55, 0x55, 0x55, 0x55, 0x55, 0x7F, 0x80, 0x00, 0xC3, 0x23, 0x3E, 0x33,
    0x00, 0xCB, 0x16, 0xA1, 0xFC, 0x5C, 0xD7, 0xDC, 0x54, 0xBA, 0xD1, 0x09, 0xD5, 0x48, 0x5D, 0xB9, 0xE9, 0x2F, 0x1D,
    0xC0, 0xB1, 0x5E, 0x83, 0xF1, 0xA2, 0x6C, 0x8A, 0x46, 0x37, 0x6B, 0x64, 0x3C, 0xFB, 0x30, 0x7E, 0xFD, 0x39, 0x20,
    0x54, 0x36, 0xC6, 0x57, 0x0C, 0x4A, 0xFC, 0xEC, 0x53, 0x6F, 0x43, 0x5D, 0x6F, 0xD7, 0x5F, 0xD7, 0xD5, 0xEA, 0xC9,
    0x42, 0xED, 0x17, 0x2A, 0x67, 0x5C, 0x0E, 0xA7, 0x35, 0x18, 0xF5, 0x63, 0x07, 0x98, 0xDD, 0xB3, 0x8F, 0x40, 0xC4,
    0x65, 0xD5, 0x3D, 0x60, 0x71, 0xA6, 0x0E, 0x34, 0x18, 0xC2, 0x89, 0x2D, 0x7F, 0x06, 0xC4, 0xC5, 0x20, 0x9B, 0x14,
    0x17, 0xFE, 0x15, 0x00, 0x74, 0x94, 0xD9, 0x2C, 0xC3, 0x4B, 0x99, 0xDB, 0xB9, 0x56, 0x6C, 0xD0, 0xC0, 0xBF, 0x5D,
    0x32, 0xCE, 0xF3, 0xF9, 0x11, 0x02, 0x7D, 0x4A, 0x5F, 0x1C, 0xEB, 0xAD, 0x5A, 0x8F, 0x06, 0xC5, 0x67, 0x1D, 0xFB,
    0x4D, 0x74, 0x7F, 0x9E, 0xD8, 0x43, 0x35, 0x3E, 0x30, 0x8E, 0x5F, 0xB5, 0xC7, 0x71, 0x85, 0xAB, 0x59, 0x19, 0xA2,
    0x61, 0xD7, 0xF8, 0x14, 0x2F, 0x56, 0x7E, 0x6B, 0x72, 0x1F, 0xB5, 0xD6, 0xD7, 0x19, 0x90, 0x21, 0x4E, 0x77, 0xB9,
    0x31, 0x75, 0x2D, 0xD4, 0xD2, 0x68, 0x60, 0xA2, 0x2E, 0x45, 0x2C, 0x24, 0xC4, 0x8F, 0x56, 0x3F, 0x93, 0x72, 0xD1,
    0x25, 0x89, 0x84, 0xB6, 0x89, 0x65, 0xAF, 0x8E, 0x11, 0x47, 0xBE, 0x84, 0x96, 0xB1, 0x8C, 0x0B, 0xF3, 0xBE, 0x53,
    0x49, 0x68, 0xD2, 0xF1, 0xB6, 0xC5, 0x7D, 0x1C, 0x42, 0x19, 0xD2, 0x74, 0x87, 0x02, 0x9D, 0x17, 0x6B, 0x53, 0x3E,
    0x90, 0x61, 0xA7, 0x5F, 0xD5, 0xC9, 0xA1, 0x7B, 0x06, 0x09, 0x22, 0xF4, 0xF5, 0x74, 0x35, 0x68, 0x31, 0xCB, 0x34,
    0xC3, 0x55, 0x06, 0xF6, 0x4C, 0x79, 0x8F, 0x9D, 0xE2, 0xEA, 0x03, 0x44, 0x13, 0x94, 0x4C, 0x4C, 0x39, 0x95, 0x60,
    0x58, 0xE5, 0x75, 0xA5, 0x65, 0x4E, 0x39, 0xC9, 0xE7, 0x7C, 0x15, 0xCA, 0xA2, 0x4F, 0x07, 0x46, 0xB4, 0xF9, 0x4F,
    0x87, 0x40, 0xA4, 0x2A, 0x7C, 0x16, 0x4C, 0x1F, 0x01, 0x96, 0xF0, 0x88, 0x40, 0xF1, 0x62, 0xFD, 0x75, 0x6D, 0x55,
    0xBD, 0x65, 0xD4, 0x0C, 0xB2, 0x37, 0x35, 0x2A, 0x35, 0x88, 0xDB, 0x25, 0xCD, 0xC3, 0x4F, 0x43, 0xF7, 0xBD, 0xAB,
    0x9B, 0x48, 0x73, 0x34, 0x47, 0x55, 0x17, 0x6C, 0x49, 0xE5, 0x07, 0x1C, 0xCD, 0xA0, 0xD5, 0x7E, 0x52, 0xC0, 0xF8,
    0x8F, 0x7F, 0x6B, 0x93, 0x24, 0xBE, 0xB3, 0x77, 0x00,
};

static const uint8_t seedphrase_share5_qr[] = {
    0x39, 0x7F, 0xCE, 0xAC, 0x22, 0x71, 0xCD, 0xFC, 0x83, 0x40, 0x56, 0xDF, 0x05, 0x49, 0x09, 0x76, 0x25, 0xA7, 0x6C,
    0x1E, 0xBB, 0xD3, 0xED, 0x02, 0x15, 0xF0, 0x84, 0x2A, 0xA4, 0xDB, 0xC5, 0x69, 0xC7, 0x4F, 0x24, 0x4A, 0x37, 0x88,
    0x33, 0xB4, 0x78, 0xCC, 0x89, 0xE0, 0x5F, 0x55, 0x55, 0x55, 0x55, 0x55, 0x7F, 0x80, 0xA2, 0x55, 0x22, 0xC2, 0x05,
    0x00, 0xF7, 0xC5, 0x51, 0x7C, 0x23, 0xF3, 0x47, 0x14, 0x34, 0x5D, 0xFF, 0xB0, 0x4F, 0x1D, 0xC0, 0x5F, 0x29, 0x11,
    0x30, 0x7A, 0x5C, 0xAD, 0xB4, 0x30, 0x7C, 0xC8, 0x75, 0x5A, 0x7E, 0x74, 0x35, 0xB4, 0x36, 0xCA, 0x1D, 0x0C, 0xA0,
    0x50, 0xF6, 0xBE, 0xA1, 0xDC, 0xFD, 0x38, 0x51, 0x03, 0x76, 0x51, 0x60, 0xCC, 0x16, 0x6B, 0x54, 0xC5, 0x7E, 0x1F,
    0x39, 0xE8, 0xC1, 0x1D, 0xFB, 0xA8, 0xF5, 0x1F, 0x29, 0x92, 0x91, 0x34, 0x65, 0xFA, 0x14, 0x31, 0x9B, 0xE0, 0x21,
    0x72, 0x45, 0x7A, 0x18, 0xBC, 0x4F, 0xD5, 0x1A, 0x13, 0x84, 0x5F, 0xCF, 0x5B, 0x73, 0x53, 0x55, 0x78, 0x0D, 0x86,
    0x57, 0x46, 0x15, 0x26, 0xAE, 0xAE, 0x11, 0x7D, 0x70, 0xFB, 0x6B, 0x43, 0x55, 0x8B, 0x5D, 0x59, 0x48, 0xC3, 0x31,
    0x59, 0xDE, 0x09, 0x05, 0xCF, 0xCC, 0x79, 0xA1, 0x25, 0x83, 0x49, 0x90, 0x2A, 0x88, 0x87, 0xF9, 0x5F, 0x15, 0xF3,
    0x47, 0x81, 0xFC, 0x9E, 0xE8, 0xCB, 0x22, 0xA6, 0xA8, 0x8D, 0x49, 0x75, 0x40, 0x54, 0x75, 0x18, 0x59, 0x9F, 0x22,
    0x31, 0xDF, 0x58, 0x3D, 0x37, 0x76, 0x7F, 0x2F, 0x1D, 0x9F, 0x12, 0xC3, 0x5F, 0x8B, 0x4A, 0xF3, 0x77, 0x66, 0x91,
    0x25, 0xEE, 0x14, 0xEE, 0xC6, 0x88, 0x40, 0x5C, 0x6C, 0x46, 0x54, 0x78, 0x72, 0x2A, 0xCE, 0xD0, 0x9B, 0xD7, 0x35,
    0xEF, 0x88, 0xCC, 0x67, 0xB0, 0xB7, 0x40, 0x6A, 0x04, 0x76, 0xA5, 0xE6, 0xB3, 0xCB, 0x58, 0x15, 0x14, 0xBD, 0xD6,
    0xEA, 0x35, 0x04, 0xD4, 0x01, 0xDE, 0x30, 0x9C, 0x67, 0xD8, 0x1C, 0x73, 0x4A, 0x18, 0xB9, 0x15, 0xCA, 0x9F, 0x28,
    0x83, 0xCB, 0x6F, 0xC6, 0x9F, 0xC4, 0x4C, 0xD1, 0x06, 0x25, 0x15, 0x55, 0xD7, 0x2D, 0x67, 0x41, 0x65, 0x0D, 0x16,
    0xA9, 0x64, 0xDB, 0xA1, 0xEC, 0x74, 0x8F, 0xF7, 0xFC, 0x78, 0x0D, 0x5C, 0xA5, 0x55, 0xB3, 0x9B, 0x27, 0xCF, 0x52,
    0x56, 0xB5, 0xE5, 0xD7, 0x50, 0x50, 0x99, 0xEC, 0xA0, 0x4E, 0x56, 0x5C, 0x80, 0x4F, 0x23, 0xC3, 0xE0, 0x74, 0x37,
    0xDF, 0xC0, 0xBB, 0xDA, 0xFE, 0x15, 0x44, 0xFF, 0x00, 0xDA, 0xC2, 0x8E, 0x03, 0xE8, 0x23, 0xFF, 0x35, 0xF3, 0x55,
    0xD7, 0xA7, 0x57, 0x09, 0x3A, 0xD6, 0x31, 0x9E, 0x1D, 0x8D, 0xD0, 0x55, 0x5D, 0xC5, 0x17, 0xB1, 0xF4, 0xBD, 0x4B,
    0x56, 0xA6, 0x36, 0x35, 0xA4, 0x7B, 0xD7, 0x66, 0x28, 0x45, 0x45, 0x64, 0xC9, 0xA0, 0x49, 0xD8, 0x6C, 0x00, 0xF5,
    0xF8, 0x7F, 0x5F, 0x41, 0xE5, 0x27, 0x67, 0x57, 0x01,
};

// The golden grids in the same order as the share string constants above.
static const uint8_t *const kSeedPhraseGoldenGrids[] = {
    seedphrase_share1_qr,
    seedphrase_share2_qr,
    seedphrase_share3_qr,
    seedphrase_share4_qr,
    seedphrase_share5_qr,
};

} // namespace

// ---------------------------------------------------------------------------
// Real-case deterministic tests (golden grids)
// ---------------------------------------------------------------------------

// Each share string must reproduce its golden QR grid byte-for-byte when
// re-encoded. The grid covers qrcode[0] (side length) plus the packed module
// bytes, so the full 408-byte buffer is compared.
TEST_F(QRCodeTest, ShareGoldenGridMatches)
{
    // The five share strings in the same order as the golden grids.
    const char *const kShareStrings[] = {
        seedphrase_share1,
        seedphrase_share2,
        seedphrase_share3,
        seedphrase_share4,
        seedphrase_share5,
    };

    for (int i = 0; i < 5; i++)
    {
        // Uppercase the share string (the front-end uppercases the hex payload
        // before requesting the QR code, see split.js).
        std::string upper = kShareStrings[i];
        for (char &c : upper)
        {
            if (c >= 'a' && c <= 'z')
            {
                c = static_cast<char>(c - 'a' + 'A');
            }
        }

        uint8_t qr[kBufLen];
        ASSERT_TRUE(encodeText(upper, qr)) << "Share " << (i + 1) << " should encode successfully";

        const uint8_t *golden = kSeedPhraseGoldenGrids[i];
        const int size = qrcodegen_getSize(qr);
        ASSERT_EQ(size, (int)golden[0]) << "Share " << (i + 1) << " QR size mismatch";
        const size_t bytes = (size * size + 7) / 8 + 1;

        EXPECT_EQ(std::memcmp(qr, golden, bytes), 0)
            << "Share " << (i + 1) << " QR grid does not match the golden reference";
    }
}

// The five golden grids must all be mutually distinct, since each share
// encodes different payload data.
TEST_F(QRCodeTest, GoldenGridsAreDistinct)
{
    const size_t bytes = (57 * 57 + 7) / 8 + 1; /* version 10 grid */
    for (int i = 0; i < 5; i++)
    {
        for (int j = i + 1; j < 5; j++)
        {
            EXPECT_NE(std::memcmp(kSeedPhraseGoldenGrids[i], kSeedPhraseGoldenGrids[j], bytes), 0)
                << "Shares " << (i + 1) << " and " << (j + 1) << " must have distinct QR grids";
        }
    }
}
